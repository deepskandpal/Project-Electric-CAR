# Keil uVision project newoled.uvprojx, settings and files
target newoled (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  output: newoled +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_SEMIHOST=1 -DFEATURE_LWIP=1 -D__ASSERT_MSG -DTARGET_LPC1768 -DTARGET_RELEASE --no_rtti -Otime -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_DEBUG_AWARENESS=1 -DTARGET_M3 -c -O3 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 --split_sections -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_ERROR_PATTERN=1 --cpu=Cortex-M3 -DDEVICE_ETHERNET=1 -DDEVICE_I2C=1 --preinclude=mbed_config.h -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DTARGET_LIKE_MBED --gnu -DMBED_BUILD_TIMESTAMP=1486100555.19 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DDEVICE_SPISLAVE=1 -DDEVICE_SERIAL_FC=1 -DDEVICE_LOCALFILESYSTEM=1 -DDEVICE_SERIAL=1 -DTARGET_LPC176X -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DTARGET_NXP -DTARGET_MBED_LPC1768 -D__MBED_CMSIS_RTOS_CM
  c include: .; img; Adafruit_GFX; SSD1306; mbed-os/.; mbed-os/docs; mbed-os/features; mbed-os/features/frameworks; mbed-os/features/frameworks/greentea-client; mbed-os/features/frameworks/greentea-client/greentea-client; mbed-os/features/frameworks/greentea-client/source; mbed-os/features/frameworks/unity; mbed-os/features/frameworks/unity/source; mbed-os/features/frameworks/unity/unity; mbed-os/features/frameworks/utest; mbed-os/features/frameworks/utest/source; mbed-os/features/frameworks/utest/utest; mbed-os/features/mbedtls; mbed-os/features/mbedtls/importer; mbed-os/features/mbedtls/inc; mbed-os/features/mbedtls/inc/mbedtls; mbed-os/features/mbedtls/src; mbed-os/features/mbedtls/platform; mbed-os/features/mbedtls/platform/inc; mbed-os/features/mbedtls/platform/src; mbed-os/features/nanostack; mbed-os/features/storage; mbed-os/features/netsocket; mbed-os/cmsis; mbed-os/drivers; mbed-os/events; mbed-os/events/equeue; mbed-os/rtos; mbed-os/rtos/rtx; mbed-os/rtos/rtx/TARGET_CORTEX_M; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3; mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM; mbed-os/hal; mbed-os/hal/storage_abstraction; mbed-os/platform; mbed-os/targets; mbed-os/targets/TARGET_NXP; mbed-os/targets/TARGET_NXP/TARGET_LPC176X; mbed-os/targets/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768; mbed-os/targets/TARGET_NXP/TARGET_LPC176X/device; mbed-os/targets/TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD; mbed-os/features/FEATURE_LWIP; mbed-os/features/FEATURE_LWIP/lwip-interface; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_NXP; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl; mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-os/targets/TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD/LPC1768.sct
  group 
    ./: mbed_config.h main.cpp
  group equeue
    mbed-os/events/equeue/: equeue.h equeue_platform.h equeue.c equeue_posix.c equeue_mbed.cpp
  group rtos
    mbed-os/rtos/: Mail.h MemoryPool.h Mutex.h Queue.h RtosTimer.h Semaphore.h Thread.h rtos.h rtos_idle.h rtos_idle.c Mutex.cpp RtosTimer.cpp Semaphore.cpp Thread.cpp
  group cmsis
    mbed-os/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_caFunc.h core_caInstr.h core_ca_mmu.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
  group utest
    mbed-os/features/frameworks/utest/utest/: unity_handler.h utest.h utest_case.h utest_default_handlers.h utest_harness.h utest_scheduler.h utest_serial.h utest_shim.h utest_specification.h utest_stack_trace.h utest_types.h
    mbed-os/features/frameworks/utest/: mbed-utest-shim.cpp
  group TARGET_NXP
    mbed-os/targets/TARGET_NXP/: mbed_rtx.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-eth/arch/TARGET_NXP/: lpc17xx_emac.h lpc_emac_config.h lpc_phy.h lwipopts_conf.h lpc17_emac.c lpc_phy_dp83848.c
  group TARGET_MBED_LPC1768
    mbed-os/targets/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: PinNames.h device.h reserved_pins.h
  group mbedtls
    mbed-os/features/mbedtls/inc/mbedtls/: aes.h aesni.h arc4.h asn1.h asn1write.h base64.h bignum.h blowfish.h bn_mul.h camellia.h ccm.h certs.h check_config.h cipher.h cipher_internal.h compat-1.3.h config.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h entropy_poll.h error.h gcm.h havege.h hmac_drbg.h md.h md2.h md4.h md5.h md_internal.h memory_buffer_alloc.h net.h oid.h padlock.h pem.h pk.h pk_internal.h pkcs11.h pkcs12.h pkcs5.h platform.h ripemd160.h rsa.h sha1.h sha256.h sha512.h ssl_cache.h ssl_ciphersuites.h ssl_cookie.h ssl_internal.h ssl_ticket.h threading.h timing.h version.h x509.h x509_crl.h x509_crt.h x509_csr.h xtea.h cmac.h config-no-entropy.h net_sockets.h platform_time.h ssl.h
  group api
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/api/: lwip_api_lib.c lwip_api_msg.c lwip_err.c lwip_netbuf.c lwip_netdb.c lwip_netifapi.c lwip_sockets.c lwip_tcpip.c
  group inc
    mbed-os/features/mbedtls/platform/inc/: platform_mbed.h
  group hal
    mbed-os/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h ethernet_api.h gpio_api.h gpio_irq_api.h emac_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c
  group netsocket
    mbed-os/features/netsocket/: CellularInterface.h EthInterface.h MeshInterface.h NetworkInterface.h NetworkStack.h Socket.h SocketAddress.h TCPServer.h TCPSocket.h UDPSocket.h WiFiAccessPoint.h WiFiInterface.h emac_stack_mem.h nsapi.h nsapi_dns.h nsapi_types.h NetworkInterface.cpp NetworkStack.cpp Socket.cpp SocketAddress.cpp TCPServer.cpp TCPSocket.cpp UDPSocket.cpp WiFiAccessPoint.cpp nsapi_dns.cpp
  group drivers
    mbed-os/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h AnalogIn.cpp BusIn.cpp BusInOut.cpp BusOut.cpp CAN.cpp Ethernet.cpp FileBase.cpp FileLike.cpp FilePath.cpp FileSystemLike.cpp I2C.cpp I2CSlave.cpp InterruptIn.cpp InterruptManager.cpp LocalFileSystem.cpp RawSerial.cpp SPI.cpp SPISlave.cpp Serial.cpp SerialBase.cpp Stream.cpp Ticker.cpp Timeout.cpp Timer.cpp TimerEvent.cpp
  group greentea-client
    mbed-os/features/frameworks/greentea-client/greentea-client/: test_env.h greentea_serial.h greentea_metrics.h
  group TARGET_LPC176X
    mbed-os/targets/TARGET_NXP/TARGET_LPC176X/: PeripheralNames.h PortNames.h gpio_object.h objects.h analogin_api.c analogout_api.c can_api.c ethernet_api.c gpio_api.c gpio_irq_api.c i2c_api.c pinmap.c port_api.c pwmout_api.c rtc_api.c serial_api.c sleep.c spi_api.c us_ticker.c
  group platform
    mbed-os/platform/: CThunk.h CallChain.h Callback.h CircularBuffer.h FunctionPointer.h PlatformMutex.h SingletonPtr.h Transaction.h critical.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_stats.h platform.h rtc_time.h semihost_api.h toolchain.h wait_api.h mbed_preprocessor.h mbed_assert.c mbed_board.c mbed_critical.c mbed_error.c mbed_interface.c mbed_mem_trace.c mbed_semihost_api.c mbed_wait_api_no_rtos.c mbed_stats.c CallChain.cpp mbed_alloc_wrappers.cpp mbed_rtc_time.cpp mbed_wait_api_rtos.cpp retarget.cpp
  group unity
    mbed-os/features/frameworks/unity/unity/: unity.h unity_config.h unity_internals.h
  group ipv4
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv4/: lwip_autoip.c lwip_dhcp.c lwip_etharp.c lwip_icmp.c lwip_igmp.c lwip_ip4.c lwip_ip4_addr.c lwip_ip4_frag.c
  group ipv6
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/ipv6/: lwip_dhcp6.c lwip_ethip6.c lwip_icmp6.c lwip_inet6.c lwip_ip6.c lwip_ip6_addr.c lwip_ip6_frag.c lwip_mld6.c lwip_nd6.c
  group priv
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/priv/: api_msg.h memp_priv.h memp_std.h tcp_priv.h tcpip_priv.h
  group events
    mbed-os/events/: Event.h EventQueue.h mbed_events.h EventQueue.cpp
  group core
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/core/: lwip_def.c lwip_dns.c lwip_inet_chksum.c lwip_init.c lwip_ip.c lwip_mem.c lwip_memp.c lwip_netif.c lwip_pbuf.c lwip_raw.c lwip_stats.c lwip_sys.c lwip_tcp.c lwip_tcp_in.c lwip_tcp_out.c lwip_timeouts.c lwip_udp.c
  group mbed-os
    mbed-os/: mbed.h
  group Adafruit_GFX
    Adafruit_GFX/: Adafruit_GFX.h Adafruit_GFX_Config.h Adafruit_SSD1306.h glcdfont.h Adafruit_GFX.cpp Adafruit_SSD1306.cpp
  group polarssl
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group device
    mbed-os/targets/TARGET_NXP/TARGET_LPC176X/device/: LPC17xx.h cmsis.h cmsis_nvic.h system_LPC17xx.h cmsis_nvic.c system_LPC17xx.c
  group arch
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip-sys/arch/: cc.h perf.h sys_arch.h lwip_checksum.c lwip_memcpy.c lwip_sys_arch.c
  group SSD1306
    SSD1306/: bold_font.h ssd1306.h standard_font.h ssd1306.cpp
  group src
    mbed-os/features/mbedtls/src/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c cmac.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs11.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c net_sockets.c sha512.c ssl_cache.c
    mbed-os/features/mbedtls/platform/src/: mbed_trng.c
  group lwip
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/lwip/: api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h etharp.h ethip6.h icmp.h icmp6.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpip.h timeouts.h udp.h
  group netif
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/: etharp.h lowpan6.h lowpan6_opts.h lwip_ethernet.h slipif.h
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/netif/: lwip_ethernet.c lwip_ethernetif.c lwip_lowpan6.c
  group TARGET_CORTEX_M
    mbed-os/rtos/rtx/TARGET_CORTEX_M/: RTX_CM_lib.h RTX_Config.h cmsis_os.h rt_Event.h rt_HAL_CM.h rt_List.h rt_Mailbox.h rt_MemBox.h rt_Memory.h rt_Mutex.h rt_OsEventObserver.h rt_Robin.h rt_Semaphore.h rt_System.h rt_Task.h rt_Time.h rt_Timer.h rt_TypeDef.h HAL_CM.c RTX_Conf_CM.c rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_OsEventObserver.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
  group storage_abstraction
    mbed-os/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
  group ppp
    mbed-os/features/FEATURE_LWIP/lwip-interface/lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group source
    mbed-os/features/frameworks/unity/source/: unity.c
    mbed-os/features/frameworks/greentea-client/source/: test_env.cpp greentea_serial.cpp greentea_metrics.cpp
    mbed-os/features/frameworks/utest/source/: unity_handler.cpp utest_case.cpp utest_default_handlers.cpp utest_greentea_handlers.cpp utest_harness.cpp utest_shim.cpp utest_types.cpp utest_stack_trace.cpp
  group TOOLCHAIN_ARM
    mbed-os/rtos/rtx/TARGET_CORTEX_M/TARGET_M3/TOOLCHAIN_ARM/: SVC_Table.S HAL_CM3.c
  group lwip-interface
    mbed-os/features/FEATURE_LWIP/lwip-interface/: EthernetInterface.h eth_arch.h lwip_stack.h lwipopts.h emac_lwip.c lwip_stack.c EthernetInterface.cpp emac_stack_lwip.cpp
  group TOOLCHAIN_ARM_STD
    mbed-os/targets/TARGET_NXP/TARGET_LPC176X/device/TOOLCHAIN_ARM_STD/: startup_LPC17xx.S sys.cpp
